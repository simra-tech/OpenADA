v {xschem version=3.4.8 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
